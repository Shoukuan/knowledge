* VERSION 1.0
**************************************************
* Generated by RH-CPA  *
**************************************************

* include statements for external Spice models

* Component = 602433-081_C2B2
.include "0002_CPA_Sim_3_602433-081_C2B2.sp"
* Component = 602433-081_C3B10
.include "0002_CPA_Sim_3_602433-081_C3B10.sp"
* Component = A36096-108_C3L22
.include "0002_CPA_Sim_3_A36096-108_C3L22.sp"
* Component = C83410-012_C3L15
.include "0002_CPA_Sim_3_C83410-012_C3L15.sp"
* Component = C83410-012_C3L17
.include "0002_CPA_Sim_3_C83410-012_C3L17.sp"
* Component = C83410-012_C3L18
.include "0002_CPA_Sim_3_C83410-012_C3L18.sp"
* Component = C83410-012_C3L20
.include "0002_CPA_Sim_3_C83410-012_C3L20.sp"
* Component = C83410-012_C3L24
.include "0002_CPA_Sim_3_C83410-012_C3L24.sp"
* Component = C83410-012_C3L26
.include "0002_CPA_Sim_3_C83410-012_C3L26.sp"
* Component = C83410-012_C3L28
.include "0002_CPA_Sim_3_C83410-012_C3L28.sp"
* Component = C83410-012_C3L29
.include "0002_CPA_Sim_3_C83410-012_C3L29.sp"
* Component = C97875-001_C3B11
.include "0002_CPA_Sim_3_C97875-001_C3B11.sp"
* Component = C97875-001_C3B9
.include "0002_CPA_Sim_3_C97875-001_C3B9.sp"
* Component = E16347-001_C2B12
.include "0002_CPA_Sim_3_E16347-001_C2B12.sp"
* Component = E16347-001_C3B17
.include "0002_CPA_Sim_3_E16347-001_C3B17.sp"
* Component = IPD031-201_U2A5
* Component = XW_XW
.include "0002_CPA_Sim_3_XW_XW.sp"
* Simulated Layout Model ...
.include "0002_CPA_Sim_3.sp"

**************************************************
*********** Complete Channel subckt **************
**************************************************

.include "0002_CPA_Sim_3_XW_XW.cpp"
.include "0002_CPA_Sim_3_IPD031-201_U2A5.cpp"

.subckt REDHAWK_PKG
+ U2A5_GND_Group U2A5_V1P0_S0_Group

* The following commented lines include PDN component Spice nodes
*+ Group_602433-081_C2B2_GND_1 Group_602433-081_C2B2_V1P0_S0_2
*+ Group_602433-081_C3B10_GND_1 Group_602433-081_C3B10_V1P0_S0_2
*+ Group_A36096-108_C3L22_GND_1 Group_A36096-108_C3L22_V1P0_S0_2
*+ Group_C83410-012_C3L15_GND_1 Group_C83410-012_C3L15_V1P0_S0_2
*+ Group_C83410-012_C3L17_GND_1 Group_C83410-012_C3L17_V1P0_S0_2
*+ Group_C83410-012_C3L18_GND_1 Group_C83410-012_C3L18_V1P0_S0_2
*+ Group_C83410-012_C3L20_GND_1 Group_C83410-012_C3L20_V1P0_S0_2
*+ Group_C83410-012_C3L24_GND_1 Group_C83410-012_C3L24_V1P0_S0_2
*+ Group_C83410-012_C3L26_GND_1 Group_C83410-012_C3L26_V1P0_S0_2
*+ Group_C83410-012_C3L28_GND_1 Group_C83410-012_C3L28_V1P0_S0_2
*+ Group_C83410-012_C3L29_GND_1 Group_C83410-012_C3L29_V1P0_S0_2
*+ Group_C97875-001_C3B11_GND_1 Group_C97875-001_C3B11_V1P0_S0_2
*+ Group_C97875-001_C3B9_GND_1 Group_C97875-001_C3B9_V1P0_S0_2
*+ Group_E16347-001_C2B12_GND_1 Group_E16347-001_C2B12_V1P0_S0_2
*+ Group_E16347-001_C3B17_GND_1 Group_E16347-001_C3B17_V1P0_S0_2

* call for component = 602433-081_C2B2
xa0002_CPA_Sim_3_602433-081_C2B2
+ Group_602433-081_C2B2_V1P0_S0_2 Group_602433-081_C2B2_GND_1
+ a0002_CPA_Sim_3_602433-081_C2B2

* call for component = 602433-081_C3B10
xa0002_CPA_Sim_3_602433-081_C3B10
+ Group_602433-081_C3B10_V1P0_S0_2 Group_602433-081_C3B10_GND_1
+ a0002_CPA_Sim_3_602433-081_C3B10

* call for component = A36096-108_C3L22
xa0002_CPA_Sim_3_A36096-108_C3L22
+ Group_A36096-108_C3L22_V1P0_S0_2 Group_A36096-108_C3L22_GND_1
+ a0002_CPA_Sim_3_A36096-108_C3L22

* call for component = C83410-012_C3L15
xa0002_CPA_Sim_3_C83410-012_C3L15
+ Group_C83410-012_C3L15_V1P0_S0_2 Group_C83410-012_C3L15_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L15

* call for component = C83410-012_C3L17
xa0002_CPA_Sim_3_C83410-012_C3L17
+ Group_C83410-012_C3L17_V1P0_S0_2 Group_C83410-012_C3L17_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L17

* call for component = C83410-012_C3L18
xa0002_CPA_Sim_3_C83410-012_C3L18
+ Group_C83410-012_C3L18_V1P0_S0_2 Group_C83410-012_C3L18_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L18

* call for component = C83410-012_C3L20
xa0002_CPA_Sim_3_C83410-012_C3L20
+ Group_C83410-012_C3L20_V1P0_S0_2 Group_C83410-012_C3L20_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L20

* call for component = C83410-012_C3L24
xa0002_CPA_Sim_3_C83410-012_C3L24
+ Group_C83410-012_C3L24_V1P0_S0_2 Group_C83410-012_C3L24_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L24

* call for component = C83410-012_C3L26
xa0002_CPA_Sim_3_C83410-012_C3L26
+ Group_C83410-012_C3L26_V1P0_S0_2 Group_C83410-012_C3L26_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L26

* call for component = C83410-012_C3L28
xa0002_CPA_Sim_3_C83410-012_C3L28
+ Group_C83410-012_C3L28_V1P0_S0_2 Group_C83410-012_C3L28_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L28

* call for component = C83410-012_C3L29
xa0002_CPA_Sim_3_C83410-012_C3L29
+ Group_C83410-012_C3L29_V1P0_S0_2 Group_C83410-012_C3L29_GND_1
+ a0002_CPA_Sim_3_C83410-012_C3L29

* call for component = C97875-001_C3B11
xa0002_CPA_Sim_3_C97875-001_C3B11
+ Group_C97875-001_C3B11_V1P0_S0_2 Group_C97875-001_C3B11_GND_1
+ a0002_CPA_Sim_3_C97875-001_C3B11

* call for component = C97875-001_C3B9
xa0002_CPA_Sim_3_C97875-001_C3B9
+ Group_C97875-001_C3B9_V1P0_S0_2 Group_C97875-001_C3B9_GND_1
+ a0002_CPA_Sim_3_C97875-001_C3B9

* call for component = E16347-001_C2B12
xa0002_CPA_Sim_3_E16347-001_C2B12
+ Group_E16347-001_C2B12_V1P0_S0_2 Group_E16347-001_C2B12_GND_1
+ a0002_CPA_Sim_3_E16347-001_C2B12

* call for component = E16347-001_C3B17
xa0002_CPA_Sim_3_E16347-001_C3B17
+ Group_E16347-001_C3B17_V1P0_S0_2 Group_E16347-001_C3B17_GND_1
+ a0002_CPA_Sim_3_E16347-001_C3B17

* call for component = XW_XW
xa0002_CPA_Sim_3_XW_XW
+ XW_GND_SINK_ XW_V1P0_S0_SINK_
+ a0002_CPA_Sim_3_XW_XW

* call for Layout Model
xa0002_CPA_Sim_3
+ U2A5_GND_Group Group_602433-081_C2B2_GND_1 Group_602433-081_C3B10_GND_1
+ Group_A36096-108_C3L22_GND_1 Group_C83410-012_C3L15_GND_1
+ Group_C83410-012_C3L17_GND_1 Group_C83410-012_C3L18_GND_1
+ Group_C83410-012_C3L20_GND_1 Group_C83410-012_C3L24_GND_1
+ Group_C83410-012_C3L26_GND_1 Group_C83410-012_C3L28_GND_1
+ Group_C83410-012_C3L29_GND_1 Group_C97875-001_C3B11_GND_1
+ Group_C97875-001_C3B9_GND_1 Group_E16347-001_C2B12_GND_1
+ Group_E16347-001_C3B17_GND_1 U2A5_V1P0_S0_Group Group_602433-081_C2B2_V1P0_S0_2
+ Group_602433-081_C3B10_V1P0_S0_2 Group_A36096-108_C3L22_V1P0_S0_2
+ Group_C83410-012_C3L15_V1P0_S0_2 Group_C83410-012_C3L17_V1P0_S0_2
+ Group_C83410-012_C3L18_V1P0_S0_2 Group_C83410-012_C3L20_V1P0_S0_2
+ Group_C83410-012_C3L24_V1P0_S0_2 Group_C83410-012_C3L26_V1P0_S0_2
+ Group_C83410-012_C3L28_V1P0_S0_2 Group_C83410-012_C3L29_V1P0_S0_2
+ Group_C97875-001_C3B11_V1P0_S0_2 Group_C97875-001_C3B9_V1P0_S0_2
+ Group_E16347-001_C2B12_V1P0_S0_2 Group_E16347-001_C3B17_V1P0_S0_2
+ XW_V1P0_S0_SINK_ XW_GND_SINK_
+ a0002_CPA_Sim_3

.ends REDHAWK_PKG
