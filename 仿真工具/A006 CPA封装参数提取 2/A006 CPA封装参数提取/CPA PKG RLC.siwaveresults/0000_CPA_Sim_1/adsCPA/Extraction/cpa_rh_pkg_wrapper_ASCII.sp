* VERSION 1.0
**************************************************
* Generated by RH-CPA  *
**************************************************

* include statements for external Spice models

* Component = CSP_BGA_BGA
.include "0000_CPA_Sim_1_CSP_BGA_BGA.sp"
* Component = FCHIP_FCHIP
* Simulated Layout Model ...
.include "0000_CPA_Sim_1.sp"

**************************************************
*********** Complete Channel subckt **************
**************************************************

.include "0000_CPA_Sim_1_CSP_BGA_BGA.cpp"
.include "0000_CPA_Sim_1_FCHIP_FCHIP.cpp"

.subckt REDHAWK_PKG
+ FCHIP_RXDATA0+_Group FCHIP_RXDATA0-_Group FCHIP_RXDATA1+_Group
+ FCHIP_RXDATA1-_Group FCHIP_RXDATA2+_Group FCHIP_RXDATA2-_Group
+ FCHIP_RXDATA3+_Group FCHIP_RXDATA3-_Group FCHIP_RXDATA4+_Group
+ FCHIP_RXDATA4-_Group FCHIP_RXDATA5+_Group FCHIP_RXDATA5-_Group
+ FCHIP_RXDATA6+_Group FCHIP_RXDATA6-_Group FCHIP_RXDATA7+_Group
+ FCHIP_RXDATA7-_Group FCHIP_TXDATA0+_Group FCHIP_TXDATA0-_Group
+ FCHIP_TXDATA1+_Group FCHIP_TXDATA1-_Group FCHIP_TXDATA2+_Group
+ FCHIP_TXDATA2-_Group FCHIP_TXDATA3+_Group FCHIP_TXDATA3-_Group
+ FCHIP_TXDATA4+_Group FCHIP_TXDATA4-_Group FCHIP_TXDATA5+_Group
+ FCHIP_TXDATA5-_Group FCHIP_TXDATA6+_Group FCHIP_TXDATA6-_Group
+ FCHIP_TXDATA7+_Group FCHIP_TXDATA7-_Group FCHIP_VSS_Group

* call for component = CSP_BGA_BGA
xa0000_CPA_Sim_1_CSP_BGA_BGA
+ BGA_VSS_Group_SINK_ BGA_TXDATA2-_Group_SINK_ BGA_TXDATA2+_Group_SINK_
+ BGA_TXDATA1-_Group_SINK_ BGA_TXDATA5-_Group_SINK_ BGA_TXDATA3+_Group_SINK_
+ BGA_TXDATA7+_Group_SINK_ BGA_TXDATA1+_Group_SINK_ BGA_TXDATA0-_Group_SINK_
+ BGA_TXDATA3-_Group_SINK_ BGA_TXDATA4-_Group_SINK_ BGA_TXDATA4+_Group_SINK_
+ BGA_TXDATA5+_Group_SINK_ BGA_TXDATA6-_Group_SINK_ BGA_TXDATA6+_Group_SINK_
+ BGA_TXDATA7-_Group_SINK_ BGA_RXDATA2+_Group_SINK_ BGA_RXDATA0+_Group_SINK_
+ BGA_RXDATA3+_Group_SINK_ BGA_RXDATA5+_Group_SINK_ BGA_RXDATA1-_Group_SINK_
+ BGA_RXDATA2-_Group_SINK_ BGA_RXDATA0-_Group_SINK_ BGA_RXDATA1+_Group_SINK_
+ BGA_RXDATA3-_Group_SINK_ BGA_RXDATA4+_Group_SINK_ BGA_RXDATA4-_Group_SINK_
+ BGA_RXDATA7+_Group_SINK_ BGA_RXDATA6-_Group_SINK_ BGA_RXDATA5-_Group_SINK_
+ BGA_RXDATA6+_Group_SINK_ BGA_RXDATA7-_Group_SINK_ BGA_TXDATA0+_Group_SINK_
+ a0000_CPA_Sim_1_CSP_BGA_BGA

* call for Layout Model
xa0000_CPA_Sim_1
+ FCHIP_RXDATA0+_Group FCHIP_RXDATA0-_Group FCHIP_RXDATA1+_Group
+ FCHIP_RXDATA1-_Group FCHIP_RXDATA2+_Group FCHIP_RXDATA2-_Group
+ FCHIP_RXDATA3+_Group FCHIP_RXDATA3-_Group FCHIP_RXDATA4+_Group
+ FCHIP_RXDATA4-_Group FCHIP_RXDATA5+_Group FCHIP_RXDATA5-_Group
+ FCHIP_RXDATA6+_Group FCHIP_RXDATA6-_Group FCHIP_RXDATA7+_Group
+ FCHIP_RXDATA7-_Group FCHIP_TXDATA0+_Group FCHIP_TXDATA0-_Group
+ FCHIP_TXDATA1+_Group FCHIP_TXDATA1-_Group FCHIP_TXDATA2+_Group
+ FCHIP_TXDATA2-_Group FCHIP_TXDATA3+_Group FCHIP_TXDATA3-_Group
+ FCHIP_TXDATA4+_Group FCHIP_TXDATA4-_Group FCHIP_TXDATA5+_Group
+ FCHIP_TXDATA5-_Group FCHIP_TXDATA6+_Group FCHIP_TXDATA6-_Group
+ FCHIP_TXDATA7+_Group FCHIP_TXDATA7-_Group FCHIP_VSS_Group
+ BGA_RXDATA0+_Group_SINK_ BGA_VSS_Group_SINK_ BGA_RXDATA0-_Group_SINK_
+ BGA_RXDATA1+_Group_SINK_ BGA_RXDATA1-_Group_SINK_ BGA_RXDATA2+_Group_SINK_
+ BGA_RXDATA2-_Group_SINK_ BGA_RXDATA3+_Group_SINK_ BGA_RXDATA3-_Group_SINK_
+ BGA_RXDATA4+_Group_SINK_ BGA_RXDATA4-_Group_SINK_ BGA_RXDATA5+_Group_SINK_
+ BGA_RXDATA5-_Group_SINK_ BGA_RXDATA6+_Group_SINK_ BGA_RXDATA6-_Group_SINK_
+ BGA_RXDATA7+_Group_SINK_ BGA_RXDATA7-_Group_SINK_ BGA_TXDATA0+_Group_SINK_
+ BGA_TXDATA0-_Group_SINK_ BGA_TXDATA1+_Group_SINK_ BGA_TXDATA1-_Group_SINK_
+ BGA_TXDATA2+_Group_SINK_ BGA_TXDATA2-_Group_SINK_ BGA_TXDATA3+_Group_SINK_
+ BGA_TXDATA3-_Group_SINK_ BGA_TXDATA4+_Group_SINK_ BGA_TXDATA4-_Group_SINK_
+ BGA_TXDATA5+_Group_SINK_ BGA_TXDATA5-_Group_SINK_ BGA_TXDATA6+_Group_SINK_
+ BGA_TXDATA6-_Group_SINK_ BGA_TXDATA7+_Group_SINK_ BGA_TXDATA7-_Group_SINK_
+ a0000_CPA_Sim_1

.ends REDHAWK_PKG
